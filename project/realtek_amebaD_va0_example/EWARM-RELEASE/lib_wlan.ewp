# IAR project lib_wlan.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\os\; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\fwlib\usb_otg\include; ..\inc\inc_hp; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\drivers\usb_class\device; ..\..\..\component\common\drivers\usb_class\device\class; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\inc\inc_hp"
  ILINK.IlinkOutputFile: lib_wlan.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../component/common/api/wifi/: wifi_simple_config_parser.c
  group @SRAM/core
    ../../../component/common/drivers/wlan/realtek/src/core/: rtw_recv.c rtw_xmit.c
  group @SRAM/hal/phydm
    ../../../component/common/drivers/wlan/realtek/src/hal/phydm/: phydm_antdiv.c phydm_cfotracking.c phydm_math_lib.c phydm_phystatus.c phydm_soml.c
  group @SRAM/hal/rtl8721d
    ../../../component/common/drivers/wlan/realtek/src/hal/rtl8721d/src/: rtl8721d_rf_onoff.c
    ../../../component/common/drivers/wlan/realtek/src/hal/rtl8721d/src/lx_bus/: rtl8721d_xmit.c
  group @SRAM/osdep
    ../../../component/common/drivers/wlan/realtek/src/osdep/freertos/: freertos_isr.c freertos_recv.c freertos_skbuff.c freertos_xmit.c lxbus_intf.c rtk_bt_if.c rtk_wlan_if.c
  group bluetooth
    ../../../component/common/bluetooth/realtek/sdk/example/bt_config/: bt_config_wifi_lib.c
    ../../../component/common/bluetooth/realtek/sdk/board/amebad/src/: rtl8721d_bt.c rtl8721d_bt_calibration.c
  group core
    ../../../component/common/drivers/wlan/realtek/src/core/: rtw_ap.c rtw_btcoex.c rtw_btcoex_soc.c rtw_btcoex_wifionly.c rtw_cmd.c rtw_debug.c rtw_ieee80211.c rtw_intfs.c rtw_io.c rtw_ioctl_set.c rtw_mi.c rtw_mlme.c rtw_mlme_ext.c rtw_mp.c rtw_odm.c rtw_pmksa_cache.c rtw_promisc.c rtw_psk.c rtw_pwrctrl.c rtw_rf.c rtw_sae.c rtw_sae_crypto.c rtw_security.c rtw_sta_mgt.c rtw_suspend.c rtw_wlan_util.c wifi_performance_monitor.c
    ../../../component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_crypto_ssl.c
  group core/efuse
    ../../../component/common/drivers/wlan/realtek/src/core/efuse/: rtw_efuse.c
  group core/rom
    ../../../component/common/drivers/wlan/realtek/ram_patch/: ram_patch_8721d.c
    ../../../component/common/drivers/wlan/realtek/src/core/rom/: rom_aes.c rom_arc4.c rom_md5.c rom_rc4.c rom_rtw_ieee80211.c rom_rtw_message_e.c rom_rtw_message_f.c rom_rtw_psk.c rom_rtw_security.c rom_rtw_wlan_util.c rom_sha1.c
  group hal
    ../../../component/common/drivers/wlan/realtek/src/hal/: hal_btcoex.c hal_btcoex_wifionly.c hal_com.c hal_com_phycfg.c hal_dm.c hal_intf.c hal_phy.c halbtccommon.c HalPwrSeqCmd.c
  group hal/btc
    ../../../component/common/drivers/wlan/realtek/src/hal/btc/: halbtc8721d.c halbtc8721d_phy.c halbtc8721dwifionly.c
  group hal/phydm
    ../../../component/common/drivers/wlan/realtek/src/hal/phydm/: phydm.c phydm_adaptivity.c phydm_adc_sampling.c phydm_antdect.c phydm_api.c phydm_auto_dbg.c phydm_cck_pd.c phydm_ccx.c phydm_debug.c phydm_dfs.c phydm_dig.c phydm_dynamictxpower.c phydm_hwconfig.c phydm_interface.c phydm_noisemonitor.c phydm_pow_train.c phydm_primary_cca.c phydm_psd.c phydm_rainfo.c phydm_rssi_monitor.c
  group hal/phydm/halrf
    ../../../component/common/drivers/wlan/realtek/src/hal/phydm/halrf/: halphyrf_iot.c halrf.c halrf_debug.c halrf_kfree.c halrf_powertracking.c halrf_powertracking_iot.c halrf_txgapcal.c
  group hal/phydm/halrf/rtl8721d
    ../../../component/common/drivers/wlan/realtek/src/hal/phydm/halrf/rtl8721d/: halhwimg8721d_rf.c halrf_8721d.c halrf_dpk_8721d.c halrf_rfk_init_8721d.c halrf_txgapk_8721d.c
  group hal/phydm/rtl8721d
    ../../../component/common/drivers/wlan/realtek/src/hal/phydm/rtl8721d/: halhwimg8721d_bb.c halhwimg8721d_mac.c phydm_hal_api8721d.c phydm_regconfig8721d.c phydm_rtl8721d.c
  group hal/rtl8721d/little_driver
    ../../../component/common/drivers/wlan/realtek/src/hal/rtl8721d/little_driver/src/: ethernet_rswlan.c rs_intfs.c rs_network.c
    ../../../component/common/drivers/wlan/realtek/src/hal/rtl8721d/little_driver/src/hw/: rs8721d_cmd.c rs8721d_halinit.c rs8721d_interrupt.c rs8721d_ops.c rs8721d_phystatus.c rs8721d_recv.c rs8721d_suspend.c rs8721d_xmit.c
  group hal/rtl8721d/src
    ../../../component/common/drivers/wlan/realtek/src/hal/rtl8721d/src/: Hal8721DPwrSeq.c rtl8721d_btcoex.c rtl8721d_cmd.c rtl8721d_dm.c rtl8721d_firmware.c rtl8721d_hal_efuse.c rtl8721d_hal_init.c rtl8721d_mp.c rtl8721d_phycfg.c rtl8721d_rf6052.c rtl8721d_rxdesc.c rtl8721d_txdesc.c
  group hal/rtl8721d/src/lxbus
    ../../../component/common/drivers/wlan/realtek/src/hal/rtl8721d/src/lx_bus/: lxbus_halinit.c lxbus_ops.c lxbus_suspend.c rtl8721d_recv.c
  group hal/rtl8721d/src/rom
    ../../../component/common/drivers/wlan/realtek/src/hal/rtl8721d/src/rom/: rom_phydm_8721d.c rom_rtl8721d_efuse.c rom_rtl8721d_hal_init.c
  group hci
    ../../../component/common/drivers/wlan/realtek/src/hci/: hci_intfs.c
    ../../../component/common/drivers/wlan/realtek/src/hci/lxbus/: lxbus_hci_intf.c
  group osdep
    ../../../component/common/drivers/wlan/realtek/src/osdep/freertos/: freertos_intfs.c freertos_ioctl.c freertos_mp.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: netdev.c
  group wlan_ram_map
    ../../../component/common/drivers/wlan/realtek/wlan_ram_map/rom/: rom_wlan_ram_map.c
    ../../../component/common/drivers/wlan/realtek/wlan_ram_map/: wlan_ram_map.c
