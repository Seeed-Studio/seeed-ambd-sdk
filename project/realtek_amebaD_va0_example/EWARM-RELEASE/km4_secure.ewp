# IAR project km4_secure.ewp, settings and files
configuration tz (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_SECURE=1
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\os; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure\; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\fwlib\usb_otg\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\drivers\usb_class\device; ..\..\..\component\common\drivers\usb_class\device\class; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; ..\inc\inc_hp; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: km4_secure.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\inc\inc_hp"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img3.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "normal"
  ILINK.IlinkOutputFile: km4_secure.axf
  ILINK.IlinkIcfFile: rtl8721dhp_image3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration tz (mp) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_SECURE=1; CONFIG_MP_INCLUDED
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img3.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "mp"
  group @PSRAM/network/ssl
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group @PSRAM/network/ssl/library
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c ecdsa.c ecp.c ecp_curves.c md.c md5.c md_wrap.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c rsa.c sha1.c sha256.c sha512.c ssl_tls.c
  group @PSRAM/network/ssl/library_s
    ../../../component/common/network/ssl/mbedtls-2.4.0/library_s/: mbedtls_nsc.c
  group @SRAM/fwlib
    ../../../component/soc/realtek/amebad/img3/: boot_img3.c secure_efuse.c
    ../../../component/soc/realtek/amebad/fwlib/ram_common/: rtl8721d_adc.c rtl8721d_ram_libc.c
    ../../../component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721dhp_intfcfg.c
  group @SRAM/fwlib/crypto
    ../../../component/soc/realtek/amebad/fwlib/crypto/: rtl8721dhp_chacha_poly1305.c rtl8721dhp_md5.c rtl8721dhp_sha.c
    ../../../component/soc/realtek/amebad/img3/: rtl8721dhp_crc.c
  group @SRAM/os
    ../../../component/os/freertos/freertos_v10.2.0/Source/portable/IAR/RTL8721D_HP/secure/: secure_context.c secure_context_port.c secure_context_port_asm.s secure_heap.c secure_init.c
  group @SRAM/user
    ../../../component/soc/realtek/amebad/img3/: secure_src.c
